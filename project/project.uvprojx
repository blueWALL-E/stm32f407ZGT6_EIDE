# Keil uVision project project.uvprojx, settings and files
target project (ARM-ADS)
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .eide\deps;..\Libraries\0_CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\0_STM32F4xx_StdPeriph_Driver\inc;..\1_user;..\Libraries\0_CMSIS\Include;..\1_user\delay;..\1_user\sys;..\1_user\usart
  asm define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  scatter file: f:\Vscode_programming\Embedded\STM32\stm32f407ZGT6_EIDE\project\STM32F407ZGTx_FLASH.ld
  group USER
    ../1_user/delay/: delay.c
    ../1_user/: main.c stm32f4xx_it.c
    ../1_user/sys/: sys.c
    ../1_user/usart/: usart.c
    ../: readme.md
  group LIB
    ../Libraries/0_STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_cryp.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash_ramfunc.c stm32f4xx_flash.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_hash.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../Libraries/0_CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Libraries/0_CMSIS/Device/ST/STM32F4xx/Source/Templates/TrueSTUDIO/: startup_stm32f40_41xxx.s
